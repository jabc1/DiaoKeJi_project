# Keil uVision project diaoke.uvprojx, settings and files
target NRF_M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diaoke +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\App\user;..\App\page;..\App\task_M;..\..\System;..\..\System\OS;..\..\System\STM32\CMSIS\CM3\CoreSupport;..\..\System\STM32\STM32F10x_StdPeriph_Driver\inc;..\..\System\STM32\CMSIS\CM3\DeviceSupport;..\..\System\GUI;..\..\System\MALLOC;..\..\System\GUI\GUI_FONT;..\..\System\FatFs;..\..\System\Device;..\..\System\Device\device_adc;..\..\System\Device\device_key;..\..\System\Device\device_LCD;..\..\System\Device\device_LED;..\..\System\Device\device_spi;..\..\System\Device\device_Touch;..\..\System\Device\device_usart;..\..\System\Device\device_NRF24L01;..\..\System\Device\device_rtc;..\..\System\Device\device_sd;..\..\System\USB\CONFIG;..\..\System\USB\LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/task_M/: app.c NRFTask.c FileTask.c ShowTask.c app.h
    ../App/user/: DK_Conf.h
  group user
    ../App/user/: NRF_Ctrl.c sd.c g_code.c TFT_control.c
  group page
    ../App/page/: Page_Main.c Page_DingWei.c Page_FileSelect.c Page_ShowCN.c Page_SetDate.c Page_SetTime.c Page_SetSYS.c
  group config
    ../App/task_M/: device_conf.h GUI_conf.h OS_conf.h stm32f10x_conf.h stm32f10x_it.c
  group Device
    ../../System/Device/: device.c
    ../../System/Device/device_LED/: device_LED.c
    ../../System/Device/device_key/: device_Key.c
    ../../System/Device/device_LCD/: device_lcd.c
    ../../System/Device/device_NRF24L01/: device_NRF24L01.c
    ../../System/Device/device_spi/: device_spi.c
    ../../System/Device/device_SD/: device_sd_sdio.c
    ../../System/Device/device_usart/: device_usart.c
    ../../System/Device/device_Touch/: device_Touch.c
    ../../System/Device/device_rtc/: device_rtc.c
  group GUI
    ../../System/GUI/: GUI.c GUI_OS.c GUI_Draw2D.c GUI_LCDAPI.c GUI_Form.c GUI_Lamp.c GUI_Button.c GUI_Key.c GUI_touch.c GUI_Menu.c GUI_Lable.c GUI_FileList.c GUI_Scrollbar.c GUI_Led.c
    ../../System/GUI/GUI_FONT/: GUI_font.c
  group System.Os
    ../../System/OS/: os.c os_systick.c os_timer.c os_a.asm os.h
  group Fatfs
    ../../System/FatFs/: ff.c diskio.c
    ../../System/FatFs/option/: ccsbcs.c
  group MALLOC
    ../../System/MALLOC/: malloc.c
  group StdPeriph_Driver
    ../../System/STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_sdio.c
  group CMSIS
    ../../System/STM32/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../System/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RVMDK
    ../../System/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
target ram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diaoke +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\..\System;..\..\System\OS;..\..\System\STM32\CMSIS\CM3\CoreSupport;..\..\System\STM32\STM32F10x_StdPeriph_Driver\inc;..\..\System\STM32\CMSIS\CM3\DeviceSupport;..\..\System\GUI;..\..\System\MALLOC;..\..\System\GUI\GUI_DRIVCE;..\..\System\GUI\FONT;..\..\System\FatFs;..\..\System\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
