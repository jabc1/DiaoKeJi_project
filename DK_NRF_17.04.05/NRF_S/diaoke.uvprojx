# Keil uVision project diaoke.uvprojx, settings and files
target NRF_S (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diaoke +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\App\user;..\App\page;..\App\task_S;..\..\System;..\..\System\OS;..\..\System\STM32\CMSIS\CM3\CoreSupport;..\..\System\STM32\STM32F10x_StdPeriph_Driver\inc;..\..\System\STM32\CMSIS\CM3\DeviceSupport;..\..\System\GUI;..\..\System\MALLOC;..\..\System\GUI\GUI_DRIVCE;..\..\System\GUI\FONT;..\..\System\FatFs;..\..\System\Device;..\..\System\Device\device_adc;..\..\System\Device\device_key;..\..\System\Device\device_LCD;..\..\System\Device\device_LED;..\..\System\Device\device_NRF24L01;..\..\System\Device\device_PWM;..\..\System\Device\device_rtc;..\..\System\Device\device_sdiosdcard;..\..\System\Device\device_spi;..\..\System\Device\device_usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/task_S/: app.c NRFTask.c CtrlTask.c MotoTask.c stm32f10x_it.c app.h
  group user
    ../App/user/: NRF_Ctrl.c DK_CX.c DK_Run.c DK_SZ.c plan.c queue.c motion_ctrl.c moto_4988.c limit.c DK_BKP.c
  group Config
    ../App/task_S/: OS_conf.h stm32f10x_conf.h device_conf.h
    ../App/user/: DK_Conf.h
  group Device
    ../../System/Device/: device.c
    ../../System/Device/device_rtc/: device_rtc.c
    ../../System/Device/device_spi/: device_spi.c
    ../../System/Device/device_TIM/: device_TIM.c
    ../../System/Device/device_usart/: device_usart.c
    ../../System/Device/device_LED/: device_LED.c
    ../../System/Device/device_NRF24L01/: device_NRF24L01.c
  group System.Os
    ../../System/OS/: os.c os_systick.c os_timer.c os_a.asm os.h
  group MALLOC
    ../../System/MALLOC/: malloc.c
  group StdPeriph_Driver
    ../../System/STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../System/STM32/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../System/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RVMDK
    ../../System/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
